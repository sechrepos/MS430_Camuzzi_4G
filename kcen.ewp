# IAR project kcen.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  General.GStackSize2: 96
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f169.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: adc.c button.c flash.c lcd.c main.c modbus_std_485.c modem.c monitor.c rtc.c sender.c timers.c uart_0.c uart_1.c ui.c
